# Repository thebenheckshow/204-tbhs-zx-kit (continued)

## EAGLE design Board/zx_kit_example.brd (continued)

Board: 2 copper layers, 174 parts (3 on the bottom side), 128 nets, no tracks yet.

File parts/zx_kit_BOM.csv (part):

"Part";"Value";"Device";"Package";"Description";"MF";"MPN";"OC_FARNELL";"OC_NEWARK";"PACKAGE";"SUPPLIER";
"32KRAM";"CY62256LL-SNXI";"CY62256LL-SNXI";"SOJ28/3";"256K (32K x 8) CMOS-Static RAM";"";"";"";"";"";"";
"32K_ROM";"27C256L";"27C256L";"PLCC-32";"CMOS EPROM";"";"AT27C256R-70JU";"1095779";"96K6554";"";"";
"157";"SN74HC157D";"SN74HC157D";"SO16";"Multiplexer used to select address lines of video RAM";"";"";"";"";"";"";
"157-1";"SN74HC157D";"SN74HC157D";"SO16";"Multiplexer used to select address lines of video RAM";"";"";"";"";"";"";
"BATT";"";"MA04-1";"MA04-1";"PIN HEADER";"";"";"unknown";"unknown";"";"";
"C1";".1";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C2";".1";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C3";".1";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C4";".1";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C5";"100pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C6";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C7";"22nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C8";"22nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C9";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C10";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C11";"10nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C12";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C13";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C14";"22nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C15";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C16";".1uf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C17";"10nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C18";"33pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C19";"33pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C20";"16pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C21";"150pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C22";"150pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C23";"22nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C24";"47nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C25";"22uf";"CPOL-USB";"PANASONIC_B";"POLARIZED CAPACITOR, American symbol";"";"";"";"";"";"";
"C26";"22nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C27";"22nf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C28";"10uf";"CPOL-USB";"PANASONIC_B";"POLARIZED CAPACITOR, American symbol";"";"";"";"";"";"";
"C29";"22uf";"CPOL-USB";"PANASONIC_B";"POLARIZED CAPACITOR, American symbol";"";"";"";"";"";"";
"C30";"22uf";"CPOL-USB";"PANASONIC_B";"POLARIZED CAPACITOR, American symbol";"";"";"";"";"";"";
"C31";"10uf";"CPOL-USB";"PANASONIC_B";"POLARIZED CAPACITOR, American symbol";"";"";"";"";"";"";
"C32";"15pf";"C-USC0805";"C0805";"CAPACITOR, American symbol";"";"";"";"";"";"";
"C33";"10uF";"CAP_CERAMIC0805";"0805";"Ceramic Capacitors";"";"";"";"";"";"";
"C34";"10uF";"CAP_CERAMIC0805";"0805";"Ceramic Capacitors";"";"";"";"";"";"";
"D1";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D2";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D3";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D4";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D5";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D6";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D7";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D8";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D9";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"D10";"";"DIODE-SOD123";"SOD123";"DIODE";"";"";"";"";"";"";
"IC1";"74LS32D";"74LS32D";"SO14";"Quad 2-input OR gate";"";"";"";"";"";"";
"IC3";"74AC04D";"74AC04D";"SO14";"Hex INVERTER";"";"";"";"";"";"";
"J1";"";"USBMC32599";"MC32599";"";"";"";"";"";"";"";
"JP1";"";"AUDIO-JACKPTH";"AUDIO-JACK";"3.5mm Audio Jack";"";"";"";"";"";"";
"JP3";"LOAD_0.1";"HEADER-1X2";"1X02_OVAL";"PIN HEADER";"";"";"";"";"";"";
"JP5";"BATT_IN_0.1";"HEADER-1X2";"1X02_OVAL";"PIN HEADER";"";"";"";"";"";"";
"K0";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K1";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K2";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K3";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K4";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K5";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K6";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K7";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K8";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"K9";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KA";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KB";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KC";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KCAPS";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KD";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KE";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KENT";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KF";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KG";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KH";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KI";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KJ";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KK";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KL";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KM";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KN";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KO";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KP";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KQ";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KR";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KS";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KSPACE";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KSYM";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KT";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KU";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KV";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KW";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KX";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KY";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"KZ";"DTS-6";"DTS-6";"DTS-6";"";"";"";"";"";"";"";
"LED1";"STAT1-ORANGE";"LED0805";"CHIPLED_0805";"LED";"";"";"";"";"";"";
"LED2";"STAT2-GREEN";"LED0805";"CHIPLED_0805";"LED";"";"";"";"";"";"";
"LED3";"Power-RED";"LED0805";"CHIPLED_0805";"LED";"";"";"";"";"";"";
"Q1";"14MHz";"CRYSTALCTS406";"CTS406";"CRYSTAL";"";"";"unknown";"unknown";"";"";
"Q2";"4.43MHz";"CRYSTALHC49S";"HC49/S";"CRYSTAL";"";"";"1667008";"unknown";"";"";
"R1";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R2";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R3";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R4";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R5";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R6";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R7";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R8";"470";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R9";"8K2";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R10";"8K2";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R11";"8K2";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R12";"8K2";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R13";"8K2";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
"R14";"8K2";"R-US_M0805";"M0805";"RESISTOR, American symbol";"";"";"";"";"";"";
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

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
